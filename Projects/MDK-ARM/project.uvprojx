# Keil uVision project project.uvprojx, settings and files
target Template (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD
  c include: ..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\CoreSupport;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\usart;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/startup/: startup_stm32f10x_md.s
  group User
    ../../User/: main.c
  group Driver/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
